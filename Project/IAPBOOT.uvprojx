# Keil uVision project IAPBOOT.uvprojx, settings and files
target Project (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: LPC1778 NXP
  pack: Keil.LPC1700_DFP.2.3.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IAPBOOT +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Drivers\include;..\Hardware\uart;..\Libraries\Core;..\Libraries\Device\include;..\User;..\Hardware\ssp0;..\Hardware\W25Q32;..\IAPLLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group lib
    ../Drivers/source/: debug_frmwrk.c lpc177x_8x_crc.c lpc177x_8x_pinsel.c lpc177x_8x_uart.c lpc177x_8x_clkpwr.c lpc177x_8x_iap.c lpc177x_8x_systick.c lpc177x_8x_gpio.c
  group main
    ../User/: main.c
  group core
    ../Startup/: startup_LPC17xx.s
    ../Libraries/Core/: core_cm3.c system_LPC177x_8x.c
  group IAPLIB
    ../IAPLLIB/: cmd_process.c
